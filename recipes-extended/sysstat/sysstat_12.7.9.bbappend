PACKAGECONFIG:append:sulka = " cron"

RDEPENDS:${PN}:append = " cronie "

PACKAGECONFIG:append:sulka-hardening = " cron"

RDEPENDS:${PN}:append:sulka-hardening = " cronie "

FILESEXTRAPATHS:prepend:sulka := "${THISDIR}/${PN}:"

AIDE_INCLUDE_DIRS:sulka = ""
AIDE_SKIP_DIRS:sulka    = ""
